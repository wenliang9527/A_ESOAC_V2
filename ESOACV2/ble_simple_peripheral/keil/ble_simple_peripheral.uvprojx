# Keil uVision project ble_simple_peripheral.uvprojx, settings and files
target ble_simple_peripheral (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_simple_peripheral
  AfterMake: fromelf.exe  --text  -c -o Output/ble_simple_peripheral.txt  Objects/ble_simple_peripheral.axf
  AfterMake: fromelf.exe  --bin -o Output/ble_simple_peripheral.bin  Objects/ble_simple_peripheral.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\components\ble\include;..\components\driver\include;..\components\modules\os\include;..\components\modules\sys\include;..\components\modules\platform\include;..\components\modules\common\include;..\components\modules\lowpow\include;..\components\modules\button;..\components\ble\include\gap;..\components\ble\include\gatt;..\code;..\usercode;..\components\ble\profiles\ble_ota
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_5_0.sct
  link misc: --feedback=feedback.txt ../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: proj_main.c ble_simple_peripheral.c ble_simple_peripheral.h
  group profiles
    ../usercode/: ESAIRble_service.c ESAIRble_service.h
  group driver
    ../components/driver/: driver_adc.c driver_codec.c driver_efuse.c driver_exti.c driver_i2s.c driver_iic.c driver_keyscan.c driver_pdm.c driver_pmu.c driver_pmu_pwm.c driver_pmu_qdec.c driver_pwm.c driver_rtc.c driver_ssp.c driver_system.c driver_timer.c driver_uart.c driver_wdt.c
  group platform
    ../components/modules/platform/source/: core_cm3_isr.c app_boot_vectors.s
  group patch
    ../components/modules/patch/: patch.c
  group lib
    ../components/ble/library/: fr8010h_stack.lib
  group OTA
    ../components/ble/profiles/ble_ota/: ota.c ota_service.c
  group IR
    ../usercode/: aircondata.c frADC.c frATcode.c frIRConversion.c frspi.c frusart.c LED.c
  group ucode
    ../usercode/: IRLearntr.c
  group userapp
    ../usercode/: app_task.c protocol.c mqtt_handler.c device_config.c
software components: CMSIS:CORE 5.6.0
